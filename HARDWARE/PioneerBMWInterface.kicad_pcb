# Repository pchmura4/BMW-Pioneer_interface

File README.md:

# BMW Pioneer Interface

Interface between BMW E46 steering wheel to control Pioneer aftermarket headunits  
Tested with BMW E46 AT71 and Pioneer MVH-X380BT headunit.  
In theory it should work with  
- 3 series E46 1999-2005
- 5 series E39 1996-2004
- 7 series E38 < 2001
- Z4 E85 2002-2008
- Mini 2001-2006

This circuit / software is more than 5 years old so some details can be wrong. First the input would be taken probably from PIN 7 in the big OEM radio connector. The outputs OUT and RING goes to 3.5mm jack plugged on the backside of the headunit. Voltage would best be taken from the switched power pin.  
The circuit can be done better, it was just a proof of concept. Better power supply, programming interface or the outputs optimization would make it a solid interface. It worked for about 2 years without any issues.

## KiCad design HARDWARE/PioneerBMWInterface.kicad_pcb

Parts:
C1: 10uF; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C2, C3: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: D_Schottky_x2_KCom_AAK; SOT-23_Handsoldering
P1, P2: CONN_01X02; PinHeader_1x02_P2.54mm_Vertical
P3: CONN_01X03; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: BC817-40; SOT-23_Handsoldering
R1, R17: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 1k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 22k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 3k5; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 47k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 5.8k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R9: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 8k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 12k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R13: 220k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 16k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 24k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: STM32F030F4P6; TSSOP-20_4.4x6.5mm_P0.65mm
U2: MCP1792T-3302H; SOT-23_Handsoldering

Connections:
1k2: R1.1, U1.14 (PB1)
3k5: R3.1, U1.13 (PA7)
5k8: R5.1, U1.12 (PA6)
8k: R7.1, U1.11 (PA5)
12k: R9.1, U1.10 (PA4)
16k: R11.1, U1.9 (PA3)
24k: R13.1, U1.8 (PA2)
GND: C1.2, C2.2, C3.2, P1.2, P2.2, P3.3, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), Q7.2 (E), Q8.2 (E), U1.1 (BOOT0), U1.15 (VSS), U2.1 (GND)
unnamed: C1.1, C2.1, P2.1, U2.3 (VIN)
unnamed: D1.1 (A), D1.2 (A), R17.2, U1.18 (PA10)
unnamed: D1.3 (K), P1.1
unnamed: Q1.1 (B), R1.2
unnamed: Q1.3 (C), R2.1
unnamed: Q2.1 (B), R3.2
unnamed: Q2.3 (C), R4.1
unnamed: Q3.1 (B), R5.2
unnamed: Q3.3 (C), R6.1
unnamed: Q4.1 (B), R7.2
unnamed: Q4.3 (C), R8.1
unnamed: Q5.1 (B), R9.2
unnamed: Q5.3 (C), R10.1
unnamed: Q6.1 (B), R11.2
unnamed: Q6.3 (C), R12.1
unnamed: Q7.1 (B), R13.2
unnamed: Q7.3 (C), R14.1
unnamed: Q8.1 (B), R15.2
unnamed: Q8.3 (C), R16.1
OUT: P3.1, R2.2, R4.2, R6.2, R8.2, R10.2, R12.2, R14.2
RING: R15.1, U1.7 (PA1)
RING_OUT: P3.2, R16.2
VCC: C3.1, R17.1, U1.4 (NRST), U1.5 (VDDA), U1.16 (VDD), U2.2 (VOUT)

Board: 2 copper layers, 52.0 x 21.0 mm, 34 parts (0 on the bottom side), 31 nets.

## Code that names these connections

File INC/main.h:

#ifndef __MAIN_H__
#define __MAIN_H__

#include "stm32f0xx.h"
#include "hardware.h"
#include "PioneerInterface.h"
#include "BMWbus.h"

#define IWDG_REFRESH      (uint32_t)(0x0000AAAA)
#define IWDG_WRITE_ACCESS (uint32_t)(0x00005555)
#define IWDG_START        (uint32_t)(0x0000CCCC)
#define IWDG_RELOAD       (469)				// max 2047, RLR has 11-bits -> (1/(40000/256))*469 = 3s

#define rxBuffSize	64

#define TIME	80
#define TIME2	500

#define RING_ON() 	GPIOA->BSRR = GPIO_ODR_1	// PA1
#define RING_OFF()	GPIOA->BRR  = GPIO_ODR_1	// PA1

#define R24k	GPIO_ODR_2	// PA2
#define R16k	GPIO_ODR_3	// PA3
#define R12k	GPIO_ODR_7	// PA7
#define R8k		GPIO_ODR_5	// PA5
#define R5k5	GPIO_ODR_6	// PA6				16k || 8k = 5.33k
#define R1k2	GPIO_ODR_1	// PB1

#define R24k_ON()		GPIOA->BSRR = R24k
#define R24k_OFF()	GPIOA->BRR  = R24k
#define R16k_ON()		GPIOA->BSRR = R16k
#define R16k_OFF()	GPIOA->BRR  = R16k
#define R12k_ON()		GPIOA->BSRR = R12k
#define R12k_OFF()	GPIOA->BRR  = R12k
#define R8k_ON()		GPIOA->BSRR = R8k
#define R8k_OFF()		GPIOA->BRR  = R8k
#define R5k5_ON()		GPIOA->BSRR = R5k5
#define R5k5_OFF()	GPIOA->BRR  = R5k5
#define R1k2_ON()		GPIOB->BSRR = R1k2
#define R1k2_OFF()	GPIOB->BRR  = R1k2

enum Button2F_t
{
	Btn2F_NOTHING,
	Pressed,
	Pressed1s
};

enum Ignition_t
{
	Ign_NOTHING,
	Pos1Acc,
	Pos3Start
};

void Delay(uint32_t);

extern volatile uint8_t rxBuffer[rxBuffSize];

#endif

## Commit log

2021-02-15 Upload files
2021-02-15 Upload board files
