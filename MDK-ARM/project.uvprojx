# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F072xB
  c include: ..\CMSIS\Include;..\CMSIS\Device\ST\STM32F0xx\Include;..\INC
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group MDK
    ../CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x6.s
  group User
    ../SRC/: main.cpp system_stm32f0xx.c hardware.cpp PioneerInterface.cpp BMWBus.cpp
